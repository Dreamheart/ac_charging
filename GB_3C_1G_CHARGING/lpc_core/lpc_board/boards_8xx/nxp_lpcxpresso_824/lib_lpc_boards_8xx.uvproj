# Keil uVision project lib_lpc_boards_8xx.uvproj, settings and files
target nxp_lpcxpresso_824 (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: board_nxp_lpcxpresso_824 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\lpc_chip\chip_8xx;..\..\..\lpc_chip\chip_8xx\config_82x;..\..\..\lpc_chip\chip_common;..\..\..\lpc_board\board_common;.\;..\..\..\..\software\CMSIS
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group bsp
    ./: board.c board_sysinit.c
