# Keil uVision project lib_lpc_chip_82x.uvproj, settings and files
target chip_82x_lib (ARM-ADS)
  device: LPC812M101 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x3FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: chip_82x_lib (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\..\software\lpc_core\lpc_chip\chip_8xx;..\..\..\..\software\lpc_core\lpc_chip\chip_8xx\config_82x;..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\software\CMSIS
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group csp
    ../../lpc_chip/chip_8xx/: acmp_8xx.c adc_8xx.c clock_8xx.c crc_8xx.c gpio_8xx.c iocon_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c swm_8xx.c syscon_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c chip_8xx.c sysinit_8xx.c
    ../chip_common/: ring_buffer.c iap.c
    ./: stopwatch_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c spim_8xx.c spis_8xx.c dma_8xx.c
