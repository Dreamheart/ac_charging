<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>iflash_nxp_lpcxpresso_824</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\app\Charging.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\GPRS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\iar_startup_lpc82x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\Meter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\app\remoteupdate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\sysinit.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\bsp\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\AT45DB081.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\Dio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\dma_uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\Eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\bsp\iap.c</name>
    </file>
  </group>
  <group>
    <name>DRV</name>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\acmp_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\adc_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\chip_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\clock_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\crc_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\dma_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\gpio_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\i2c_common_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\i2cm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\i2cs_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\iocon_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\pinint_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\pmu_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\sct_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\sct_pwm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\spi_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\spim_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\spis_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\stopwatch_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\swm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\syscon_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\sysinit_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\uart_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\wkt_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\lpc_core\lpc_chip\chip_8xx\wwdt_8xx.c</name>
    </file>
  </group>
</project>


