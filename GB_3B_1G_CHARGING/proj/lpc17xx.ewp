# IAR project lpc17xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1778 NXP LPC1778
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\net; ..\net\uip; ..\net\lpc177x_8x_port; ..\inc; ..\app; ..\Bsp; ..; ..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\Drivers\include; ..\FreeRTOS\portable; ..\FreeRTOS\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: lpc17xx.hex
  ILINK.IlinkOutputFile: lpc17xx.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\LPC1778.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\inc; ..\net
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: LPC1768_Flash.icf
  group app
    ../app/: Analog.c Charging.c Disp.c GPRS.c hwtst.c Main.c Meter.c Peer.c startup_LPC177x_8x.s
  group bsp
    ../Bsp/: Ad.c Cans.c Dio.c Eeprom.c Key.c Lcd.c Rtc.c Uart.c
  group bsp/Font
    ../Bsp/: Fontlib.c
  group drv
    ../Drivers/source/: lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_eeprom.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_mci.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c
    ../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
